OECONF:append:class-nativesdk = "\
    --openssl=${WORKDIR}/recipe-sysroot/usr/local/oe-sdk-hardcoded-buildpath/sysroots/${SDK_SYS}/usr \
    --xerces3=${WORKDIR}/recipe-sysroot/usr/local/oe-sdk-hardcoded-buildpath/sysroots/${SDK_SYS}/usr \
"
