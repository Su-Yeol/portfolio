TOOLCHAIN_TARGET_TASK:append = " \
    paho-mqtt-c \
    boost \
    nats-c \
    openssl \
    openssl-dev \
    opencv-dev \
    poco \
    poco-dev \
    python3-numpy \
    proj \
    proj-dev \
    rapidjson \
    katech-adaptivemachine-arxmls \
    katech-applications-arxmls \
    katech-common-machine-arxmls \
    katech-interfaces-arxmls \
    katech-network-arxmls \
    ara-arxmls \
    libstdc++-dev \
    libstdc++-staticdev \
    glibc \
    jansson-dev \
"
#TOOLCHAIN_TARGET_TASK:remove = " \
#    apd-adaptivemachine-arxmls \
#    apd-applications-arxmls \
#    apd-common-machine-arxmls \
#    apd-interfaces-arxmls \
#    apd-network-arxmls \
#    apd-fusionmachine-arxmls \
#    apd-radarfusionmachine-arxmls \
#    apd-radarfusionmachine-ucm-ota-client-dev \
#    apd-radarfusionmachine-ucm-pkgmgr-sample-dev \
#    apd-radarfusionmachine-ucm-vehicle-driver-app-dev \
#    apd-radarfusionmachine-ucm-vehicle-state-manager-app-dev \
#    apd-radarfusionwrsomeipmachine-arxmls \
#    apd-radarfusionddsmachine-arxmls \
#    apd-minimalmachine-applications-arxmls \
#    apd-minimalmachine-arxmls \
#    apd-minimalmachine-interfaces-arxmls \
#    apd-minimalmachine-network-arxmls \
#    apd-minimalmachine-ucm-package-manager-dev \
#    apd-minimalmachine-ucm-vehicle-package-manager-dev \
#    apd-radarmachine-arxmls \
#"
