BBCLASSEXTEND .= " nativesdk"

