# RadarFusionMachine 관련 SDK 패키지 제외
TOOLCHAIN_TARGET_TASK:remove = " \
    apd-radarfusionmachine-arxmls \
    apd-radarfusionmachine-ucm-ota-client-dev \
    apd-radarfusionmachine-ucm-pkgmgr-sample-dev \
    apd-radarfusionmachine-ucm-vehicle-driver-app-dev \
    apd-radarfusionmachine-ucm-vehicle-state-manager-app-dev \
    apd-radarfusionwrsomeipmachine-arxmls \
    apd-radarfusionddsmachine-arxmls \
"


