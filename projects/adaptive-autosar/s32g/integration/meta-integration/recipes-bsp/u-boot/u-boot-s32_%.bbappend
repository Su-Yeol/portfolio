FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Update-for-katech-platform-s32g274ardb-changed.patch"
SRC_URI += "file://0002-config-extra-env-setting.patch"

